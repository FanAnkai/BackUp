# Keil uVision project actual_vdda.uvprojx, settings and files
target STM32F051 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: actual_vdda +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051,
  c include: .\User;.\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates;.\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;.\Libraries\STM32F0xx_StdPeriph_Driver\src;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F0xx\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051.s
  group StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ./User/: main.c
